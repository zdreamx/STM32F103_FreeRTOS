# Keil uVision project STM32F103_FreeRTOS.uvprojx, settings and files
target STM32F103_FreeRTOS (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F103R6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103_freertos +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103x6
  c include: ..\USER;..\HARDWARE;..\FreeRTOS\include;..\FreeRTOS\config;..\TaskAPP;..\HALLIB\STM32F1xx_HAL_Driver\Inc;..\FreeRTOS\portable\GCC\ARM_CM3;..\Device\ST\STM32F1xx\Include
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group StartUp
    ../startup/: startup_stm32f103x6.s
  group HALLIB
    ../HALLIB/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_gpio.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_rcc.c stm32f1xx_hal_tim.c stm32f1xx_hal_uart.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_pwr.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_rcc_ex.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/GCC/ARM_CM3/: port.c
  group FreeRTOS_CONFIG
    ../FreeRTOS/config/: FreeRTOSConfig.h
  group HARDWARE
    ../HARDWARE/: led.c
  group USER
    ./: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c system_stm32f1xx.c
  group TaskApp
    ../TaskAPP/: led_task.c run_task.c
  group README
    ../: readme.md readme_en.md
software components: CMSIS:CORE 5.3.0
